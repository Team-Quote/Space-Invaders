# Keil uVision project Project.uvprojx, settings and files
target Project (6240000::V6.24::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..;.\drivers;.\modules
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ../src/: startup.s
    ./: tm4c123gh6pm.h SpaceInvaders.c
    ./drivers/: ADC0SS1.c PLL.c Nokia5110.c Timer1A.c Timer0.c DAC.c
    ./modules/: LED_features.c SW_features.c Sound.c
software components: CMSIS:CORE 5.6.0
